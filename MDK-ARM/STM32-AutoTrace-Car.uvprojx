# Keil uVision project STM32-AutoTrace-Car.uvprojx, settings and files
target STM32-AutoTrace-Car (5060960::V5.06 update 7 (build 960)::.\ARMCompiler506_b960)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32-AutoTrace-Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/Motor;../User/Sys;../User/Sensor;../Mode/Curve;../Mode/LineFollowSequence;../Mode/Circle;../User/LineFollow;../Mode/Triangle;../Mode/ModeChange
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User
    ../User/Sys/: sys.c
    ../User/Motor/: motor.c
    ../User/Sensor/: sensor.c
    ../User/LineFollow/: linefollow.c
    ../Mode/Circle/: circle.c
    ../Mode/Curve/: curve.c
    ../Mode/LineFollowSequence/: linefollowsequence.c
    ../Mode/ModeChange/: mode.c
    ../Mode/Triangle/: triangle.c
  group Test
    ../User/Sensor/: sensor_test.c
software components: CMSIS:CORE 4.3.0
